# Keil uVision project KEY_Proj.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: KEY_Proj +hex
  c flags: Optim=1
  c include: .\MAIN;.\NXPLPC11XX
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: KEY_Proj.sct
  group Source Group 1
    ./: startup_LPC11xx.s
  group MAIN
    ./MAIN/: main.c
  group NXPLPC11XX
    ./NXPLPC11XX/: nxplpc11xx.c
