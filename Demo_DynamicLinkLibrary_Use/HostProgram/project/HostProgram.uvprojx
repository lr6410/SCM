# Keil uVision project HostProgram.uvprojx, settings and files
target HostProgram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HostProgram +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\source\Startup;..\source\FWLib\inc;..\source\Support
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\source\Sct\HostProgram.sct
  group Startup
    ../source/Startup/: startup_stm32f40_41xxx.s
  group FWLib
    ../source/FWLib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
  group User
    ../source/User/: main.c
  group unit
    ../source/User/unit/: gpio.c unit_public.c
  group module
    ../source/User/module/: led.c module_public.c
  group service
    ../source/User/service/: DynamicLinkLibraryLoader.c
software components: CMSIS:CORE 5.1.1, Device:Startup 2.6.2
