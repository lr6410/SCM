# Keil uVision project DynamicLinkLibrary.uvprojx, settings and files
target DynamicLinkLibrary (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DynamicLinkLibrary +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o   ../source/Output/@L.bin    ../source/Output/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\source\Startup;..\source\FWLib\inc;..\source\Support
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\source\Sct\DynamicLinkLibrary.sct
  group assembly
    ../source/User/DynamicLinkLibrary/: assembly.s
  group DynamicLinkLibrary
    ../source/User/DynamicLinkLibrary/: DynamicLinkLibrary.c
